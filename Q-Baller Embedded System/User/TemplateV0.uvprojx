# Keil uVision project TemplateV0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TemplateV0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\Algorithm;..\Data;..\System;..\Utility;..\User;..\Project
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Main/: Main.c
  group Project
    ../Project/: ProjectVariable.c Function.c Initialization.c Loop.c Mode.c PROJECT.c InControl.c PostControl.c PreControl.c
  group Utility
    ../Utility/: UTILITY.c Encoder.c Gpio.c Pwm.c Timer.c Usart.c
  group Data
    ../Data/: DATA.c Variable.c Command.c Static.c Status.c
  group System
    ../System/: SYS.c startup_stm32f40_41xxx.s
  group Algorithm
    ../Algorithm/: ALGORITHM.c Attitude.c DataProcess.c Controller.c Filter.c Matrix.c
